# Keil uVision project Template.uvprojx, settings and files
target Template (6160000::V6.16::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=3
  c misc: -fdebug-macro -Wno-invalid-source-encoding
  c include: ..\USER;..\CMSIS\Include;..\Device\Include;..\MH245x_StdPeriph_Driver\inc;..\SYSTEM\usart;..\BSP\BSP_QSPI;..\BSP\LCD;..\BSP\BSP_DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x1fff000
  memory RVCT9: RAM 0x20000000 size 0x140000
  scatter file: .\ARMClang.sct
  group USER
    ./: main.c
  group Config
    ./: memory.h
  group CMSIS
    ../Device/Source/: system_mh2457.c
    ../Device/Source/ARM/: startup_mh245x.s
  group FWLib
    ../MH245x_StdPeriph_Driver/src/: mh245x_adc.c mh245x_cache.c mh245x_can.c mh245x_crc.c mh245x_dac.c mh245x_dcmi.c mh245x_dma.c mh245x_dma2d.c mh245x_dsi.c mh245x_eth.c mh245x_exti.c mh245x_fsmc.c mh245x_gpio.c mh245x_hspi.c mh245x_i2c.c mh245x_iwdg.c mh245x_jpeg.c mh245x_ltdc.c mh245x_misc.c mh245x_otp.c mh245x_pwr.c mh245x_qspi.c mh245x_rtc.c mh245x_sdio.c mh245x_sdram.c mh245x_spi.c mh245x_sysctrl.c mh245x_tim.c mh245x_trng.c mh245x_usart.c mh245x_wwdg.c peripheral.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
  group BSP
    ../BSP/BSP_QSPI/: bsp_qspi.c
    ../BSP/LCD/: lcd_init.c lcd.c
    ../BSP/BSP_DMA/: bsp_dma.c
